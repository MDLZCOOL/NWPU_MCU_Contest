# Keil uVision project STM32H750XBH6.uvprojx, settings and files
target EXT_Flash_SPI (6220000::V6.22::ARMCLANG)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: test.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx,EXT_Flash_SPI,LV_LVGL_H_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Drivers\User\Inc;..\LVGL;..\LVGL\src;..\LVGL\src\core;..\LVGL\src\draw;..\LVGL\src\draw\arm2d;..\LVGL\src\draw\nxp\pxp;..\LVGL\src\draw\nxp\vglite;..\LVGL\src\draw\nxp;..\LVGL\src\draw\sdl;..\LVGL\src\draw\stm32_dma2d;..\LVGL\src\draw\sw;..\LVGL\src\draw\swm341_dma2d;..\LVGL\src\extra;..\LVGL\src\extra\layouts\flex;..\LVGL\src\extra\layouts\grid;..\LVGL\src\extra\layouts;..\LVGL\src\extra\libs;..\LVGL\src\extra\libs\bmp;..\LVGL\src\extra\libs\ffmpeg;..\LVGL\src\extra\libs\freetype;..\LVGL\src\extra\libs\fsdrv;..\LVGL\src\extra\libs\gif;..\LVGL\src\extra\libs\png;..\LVGL\src\extra\libs\qrcode;..\LVGL\src\extra\libs\rlottie;..\LVGL\src\extra\libs\sjpg;..\LVGL\src\extra\others;..\LVGL\src\extra\others\fragment;..\LVGL\src\extra\others\gridnav;..\LVGL\src\extra\others\ime;..\LVGL\src\extra\others\imgfont;..\LVGL\src\extra\others\monkey;..\LVGL\src\extra\others\msg;..\LVGL\src\extra\others\snapshot;..\LVGL\src\extra\themes;..\LVGL\src\extra\themes\basic;..\LVGL\src\extra\themes\default;..\LVGL\src\extra\themes\mono;..\LVGL\src\extra\widgets;..\LVGL\src\extra\widgets\animimg;..\LVGL\src\extra\widgets\calendar;..\LVGL\src\extra\widgets\chart;..\LVGL\src\extra\widgets\colorwheel;..\LVGL\src\extra\widgets\imgbtn;..\LVGL\src\extra\widgets\keyboard;..\LVGL\src\extra\widgets\led;..\LVGL\src\extra\widgets\list;..\LVGL\src\extra\widgets\menu;..\LVGL\src\extra\widgets\meter;..\LVGL\src\extra\widgets\msgbox;..\LVGL\src\extra\widgets\span;..\LVGL\src\extra\widgets\spinbox;..\LVGL\src\extra\widgets\spinner;..\LVGL\src\extra\widgets\tabview;..\LVGL\src\extra\widgets\tileview;..\LVGL\src\extra\widgets\win;..\LVGL\src\font;..\LVGL\src\hal;..\LVGL\src\misc;..\LVGL\src\widgets;..\LVGL\examples\porting;..\LVGL\demos;..\LVGL\demos\music;..\LVGL\my_gui\custom;..\LVGL\my_gui\generated;..\LVGL\my_gui\generated\guider_customer_fonts;..\LVGL\my_gui\generated\guider_fonts;..\LVGL\my_gui\generated\images;..\Sensors\AHT20;..\Sensors\BMP280;..\Sensors\I2C_dependent;..\FatFs;..\LogicCode
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c rtc.c tim.c
    ../LogicCode/: swapArray.c
    ../Drivers/User/Src/: lcd_pwm.c
  group Drivers/User
    ../Drivers/User/Src/: led.c usart.c sdram.c lcd_rgb.c touch_iic.c touch_800x480.c sdmmc_sd.c
    ../FatFs/: diskio.c ff.c ff_gen_drv.c ffunicode.c sd_diskio.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cordic.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dfsdm_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_dts.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_fmac.c stm32h7xx_hal_gfxmmu.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_ospi.c stm32h7xx_hal_otfdec.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pssi.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_smbus_ex.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_cordic.c stm32h7xx_ll_crc.c stm32h7xx_ll_crs.c stm32h7xx_ll_dac.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_fmac.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_usb.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group LVGL
    ../LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../LVGL/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../LVGL/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_gpu_nxp_vglite.c
    ../LVGL/src/draw/nxp/: lv_gpu_nxp.c
    ../LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/src/extra/layouts/grid/: lv_grid.c
    ../LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ../LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../LVGL/src/extra/others/monkey/: lv_monkey.c
    ../LVGL/src/extra/others/msg/: lv_msg.c
    ../LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/src/extra/widgets/chart/: lv_chart.c
    ../LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/src/extra/widgets/led/: lv_led.c
    ../LVGL/src/extra/widgets/list/: lv_list.c
    ../LVGL/src/extra/widgets/menu/: lv_menu.c
    ../LVGL/src/extra/widgets/meter/: lv_meter.c
    ../LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/src/extra/widgets/span/: lv_span.c
    ../LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/src/extra/widgets/win/: lv_win.c
    ../LVGL/src/extra/: lv_extra.c
    ../LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_Driver
    ../LVGL/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group LVGL_Demo
    ../LVGL/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../LVGL/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
  group LVGL/my_gui
    ../LVGL/my_gui/generated/: events_init.c gui_guider.c widgets_init.c setup_scr_screen.c setup_scr_screen_1.c setup_scr_screen_2.c setup_scr_screen_3.c setup_scr_screen_4.c setup_scr_screen_5.c setup_scr_screen_6.c setup_scr_about.c setup_scr_usage.c
    ../LVGL/my_gui/custom/: custom.c
    ../LVGL/my_gui/generated/guider_fonts/: lv_font_nwpuname_50.c lv_font_SourceHanSerifSC_Regular_12.c lv_font_SourceHanSerifSC_Regular_16.c lv_font_SourceHanSerifSC_Regular_30.c lv_font_SourceHanSerifSC_Regular_50.c lv_font_SourceHanSerifSC_Regular_40.c lv_font_montserratMedium_16.c lv_font_SourceHanSerifSC_Regular_20.c lv_font_SourceHanSerifSC_Regular_25.c lv_font_nwpuname_25.c lv_font_Abel_regular_24.c lv_font_Abel_regular_25.c lv_font_SourceHanSerifSC_Regular_18.c lv_font_Alatsi_Regular_13.c lv_font_montserratMedium_14.c lv_font_montserratMedium_19.c lv_font_SourceHanSerifSC_Regular_14.c lv_font_SourceHanSerifSC_Regular_15.c lv_font_HarmonyOS_Sans_Regular_30.c lv_font_HarmonyOS_Sans_Regular_50.c lv_font_HarmonyOS_Sans_SC_Regular_16.c lv_font_HarmonyOS_Sans_SC_Regular_18.c lv_font_HarmonyOS_Sans_SC_Regular_20.c lv_font_HarmonyOS_Sans_SC_Regular_25.c lv_font_HarmonyOS_Sans_SC_Regular_30.c lv_font_HarmonyOS_Sans_SC_Regular_40.c lv_font_HarmonyOS_Sans_SC_Regular_50.c lv_font_HarmonyOS_Sans_SC_Regular_14.c lv_font_HarmonyOS_Sans_SC_Regular_15.c lv_font_SourceHanSerifSC_Regular_21.c lv_font_ArchitectsDaughter_35.c lv_font_ArchitectsDaughter_40.c
    ../LVGL/my_gui/generated/images/: _NWPU_LOGO_alpha_200x200.c _humi_alpha_80x80.c _pressure_alpha_70x70.c _temp_alpha_70x70.c _NWPU_LOGO_alpha_120x120.c _brightness_alpha_50x50.c _GPS_alpha_50x50.c _wifi_alpha_50x50.c _time_alpha_50x50.c _bluetooth_alpha_40x40.c _Espressif_Standard_Logo_CN_Horizontal_alpha_165x50.c _logo_lvgl_alpha_150x57.c _STM32_alpha_60x60.c _Espressif_Standard_Logo_CN_Horizontal_alpha_231x70.c _logo_lvgl_alpha_184x70.c _STM32_alpha_70x70.c _NXP_Logo_RGB_Colour_alpha_143x70.c _NXP_Logo_RGB_Colour_alpha_180x90.c
    ../LVGL/my_gui/generated/guider_customer_fonts/: lv_customer_font_HarmonyOS_Sans_SC_Regular_30.c
  group Sensors
    ../Sensors/AHT20/: aht20.c
    ../Sensors/BMP280/: bmp280.c
    ../Sensors/I2C_dependent/: i2c.c
software components: CMSIS:CORE 5.5.0
